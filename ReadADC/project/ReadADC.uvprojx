# Keil uVision project ReadADC.uvprojx, settings and files
target ReadADC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ReadADC
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\lib\CMSIS\Include;..\src;..\lib\MKL46Z
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: .\RTE\Device\MKL46Z256VLL4\MKL46Z256xxx4_flash.scf
  group src
    ../src/: adc.c main.c PWM.c Led.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
